## nrf/boards/raytac/mdbt50q_cx_40/board.yml
```yaml
board:
  name: raytac_mdbt50q_cx_40
  full_name: MDBT50Q-CX-40
  vendor: raytac
  socs:
  - name: nrf52840
```
